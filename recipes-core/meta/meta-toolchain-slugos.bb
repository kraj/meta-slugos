PR = "r1"

TOOLCHAIN_HOST_TASK   = "task-slugos-toolchain-host"
TOOLCHAIN_TARGET_TASK = "task-slugos-toolchain-target"

require recipes-core/meta/meta-toolchain.bb
SDK_SUFFIX = "toolchain-slugos"
