# this will prepend this layer to FILESPATH
FILESEXTRAPATHS := "${THISDIR}/${PN}-${PV}"
#PRINC = "0"
