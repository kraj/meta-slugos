# this will prepend this layer to FILESPATH
FILESEXTRAPATHS := "${THISDIR}/${PN}"
#PRINC = "0"
